# Keil uVision project FATFS.uvprojx, settings and files
target STM32F407VETx (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FATFS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\HARDWARE;.\fatfs;.\Libraries\CMSIS;.\Libraries\FWLIB\inc;.\Libraries\SYSTEM\delay;.\Libraries\SYSTEM\sys;.\Libraries\SYSTEM\usart;.\FreeRTOS_LIB\include;.\FreeRTOS_LIB\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CMSIS
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group SYSTEM
    ./Libraries/SYSTEM/delay/: delay.c
    ./Libraries/SYSTEM/sys/: sys.c
    ./Libraries/SYSTEM/usart/: usart.c
  group FWLIB
    ./Libraries/FWLIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c
  group HARDWARE
    ./HARDWARE/: key.c led.c w25qxx.c sdio_sdcard.c spi.c
  group FATFS
    ./fatfs/: diskio.c exfuns.c ff.c ffsystem.c ffunicode.c
  group FreeRTOS
    ./FreeRTOS_LIB/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS_LIB/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS_LIB/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.5.0
